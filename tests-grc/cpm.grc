<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>digital_cpmmod_bc</key>
<param><key>id</key><value>digital_cpmmod_bc_0</value></param>
<param><key>type</key><value>analog.cpm.LREC</value></param>
<param><key>mod_index</key><value>0.5</value></param>
<param><key>L</key><value>4</value></param>
<param><key>samples_per_symbol</key><value>4</value></param>
</block>
<block>
<key>trellis_viterbi_x</key>
<param><key>id</key><value>trellis_viterbi_x_0</value></param>
<param><key>final_state</key><value>-1</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>type</key><value>i</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_cpmmod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
